Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2021-08-06T15:32:43
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20170223_1515(x64) - Exporter 18.0.0.420 - Alternate UI 18.0.0.420
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Fri Aug 06 15:32:43 2021 * Host: DESKTOP-JA1LLOH * Database: C:\Users\Vlad\AppData\Local\Temp\{3FDBEB54-2FEE-4DBE-BBD5-0F0380475938}\ifc * Database version: 5507 * Database creation date: Fri Aug 06 15:32:42 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Fri Aug 06 15:32:42 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Fri Aug 06 15:32:42 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcFlowController: 1039F-104 Kitchen faucet with dishwasher valve, 1039F-104(2021):1039F-104 Kitchen faucet with dishwasher valve:367893
In: Level 1
Type - PredefinedType: FAUCET; Material: Brass
Type - Dimensions - InletConnectionSize: 10 mm; Projection: 178 mm
Type - General - Author: BIMstone; BIMObjectName: 1039F-104(2021); ManufacturerName: Oras; ManufacturerURL: http://www.oras.com; NBSDescription: Water supply fittings for sinks; NBSReference: 45-35-70/345; ProductInformation: Kitchen faucet with high spout and dishwasher valve with ceramic cartridge 90° rotation for ON/OFF; Revision: n/a; Uniclass2: Pr_40_30_96_78; Uniclass2015Description: Shower manual water supply sets; Uniclass2015Reference: Pr_40_30_96_78; Version: 1; VersionDate: 19/07/2021
Type - Green Building Properties - Customs Code: 84818011; EAN Number: 6414150098758; EN Standard: EN 817; LVI Number: 6219181; Noise Class: I (ISO 3822); NRF Number: 4200471; RSK Number: 8311532
Type - Identity Data - Catalog Drawing URL: http://static.oras.com/catdrw/1039F-104; Class: Single lever;; Dimension Drawing URL: http://static.oras.com/dimdrw/1039F-104; FDV Document URL: http://www.oras.com/datasheet/1039F-104/en/fdv; Flow Drawing URL: http://static.oras.com/flowchart/1039F-104; Group: Kitchen faucets; Long Marketing: Kitchen faucet with high spout and dishwasher valve with ceramic valve 90° rotation for ON/OFF. Spout’s swing angle is factory preset at 120° (can be limited to 0° or 60°). There are also in-built limitation options for water temperature and maximum flow-rate. F = with flexible pipes; Manufacturer: Oras; Market: INT;FIN;NOR;SWE;POL;RUS;EST;LTU;LVA;UKR; Model: 1039F-104 Kitchen faucet with dishwasher valve; Name_en: 1039F-104 Kitchen faucet with dishwasher valve; OmniClass Number: 23.45.55.00; OmniClass Title: Sanitary Faucets, Wastes; Package external Dimensions: 754 x 334 x 63; Package Weight: 2.14 kg; Product Code: 1039F-104; Product Datasheet: http://www.oras.com/datasheet/1039F-104/en; Product Family: Oras Safira; Product Image URL: http://static.oras.com/image/1039F-104; Product URL: http://static.oras.com/1039F-104; Technical DataSheet URL: http://www.oras.com/datasheet/1039F-104/en; Type Name: 1039F-104 Kitchen faucet with dishwasher valve
Type - Materials and Finishes - FaucetMainMaterial: Brass
Type - Mechanical - Advanced Features: 3S-Installation; Connection: FlexibleInletPipes; Connection Size: G3/8; Dishwasher Valve: Dishwasher valve; DN Size: DN8; Flow Rate At 300kPa With Flow Controller: 0.0208357 m3/s; Installation and Maintenance: http://static.oras.com/manual/1039F-104; Installation Type: Deck mounted; Lever Handle: Lever with H+C symbol; Max. Hot Water Supply: 70 kg/K/s3; Mechanical Parts: 40Cartridge; Mounting Holes: 1MountingHole; Pressure Loss With Flow 02ls With Flow Reducers: 240000 Pa; Spare Parts: http://static.oras.com/sp/1039F-104; Spout Swivel Range: 110° (85°/65°); Spout Type: Swivel spout;; Temperature: Temperature limiter; Temperature Adjustments: Temperature limiter
Type - Other - Category: Plumbing Fixtures; AccessibilityPerformance: n/a; AssetType: Fixed; Brand: Oras; CodePerformance: n/a; Color: Chrome; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: 1039F-104(2021); Features: Single lever;; Finish: Polished; Grade: n/a; Material: Brass; ModelNumber: n/a; ModelReference: 1039F-104; Name: 1039F-104 Kitchen faucet with dishwasher valve; ReplacementCost: n/a; Shape: Sculptured; Size: 55x260x340 mm; SustainabilityPerformance: n/a; WarrantyDescription: http://warranty.oras.com; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Constraints - DefaultElevation: 900 mm; Host: Level : Level 1; Level: Level: Level 1; Offset: 0 mm
Dimensions - Area: 0.12186 m2; Volume: 0.00477761 m3
Identity Data - Mark: 10
Mechanical - System Classification: Domestic Hot Water,Domestic Cold Water
Other - AssetIdentifier: n/a; Barcode: n/a; Family: 1039F-104(2021): 1039F-104 Kitchen faucet with dishwasher valve; Family and Type: 1039F-104(2021): 1039F-104 Kitchen faucet with dishwasher valve; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: 1039F-104(2021): 1039F-104 Kitchen faucet with dishwasher valve; Type Id: 1039F-104(2021): 1039F-104 Kitchen faucet with dishwasher valve; WarrantyStartDate: n/a
Phasing - Phase Created: New Construction
